Commit message: Update 06_pantilt.urdf

File: urdf/06_pantilt.urdf (robot description, URDF)
Before this commit: robot pan_tilt, 4 links, 3 joints
Links:
- link base_link: geometry visual mesh filename=package://pantilt_ros/meshes/baza.STL
